# Keil uVision project rclight.uvprojx, settings and files
target Target 1 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F030F4 STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.5.0
  cpu: IROM(0x08000000,0x4000) IRAM(0x20000000,0x1000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: rclight
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c include: .\Lib;.\User
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group User
    ./User/: main.c
  group Lib
    ./Lib/: delay.c func.c
software components: CMSIS:CORE 5.0.1, Device:Startup 2.2.3
